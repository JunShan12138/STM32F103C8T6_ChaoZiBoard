# Keil uVision project Project.uvprojx, settings and files
target Target (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB
  c include: ..\User\App\inc;..\User\Bsp\inc;..\STM32F10x_Library\STM32F1xx_HAL_Driver\Inc;..\STM32F10x_Library\STM32F1xx_HAL_Driver\Inc\Legacy;..\STM32F10x_Library\CMSIS\STM32F1xx\Include;..\STM32F10x_Library\CMSIS\Core;..\User\Bsp\inc;..\ThirdParty\CortexRTOS\include;..\ThirdParty\CortexRTOS\port\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User/App
    ../User/App/src/: main.c stm32f1xx_it.c system_stm32f1xx.c
  group User/Bsp
    ../User/Bsp/src/: bsp.c bsp_timer.c bsp_hard_timer.c bsp_cpu_clock.c bsp_led.c bsp_switch.c bsp_uart.c
  group CortexRTOS/port
    ../ThirdParty/CortexRTOS/port/: cm3_os_switch.c
  group CortexRTOS/src
    ../ThirdParty/CortexRTOS/src/: os_task.c
  group CMSIS
    ../STM32F10x_Library/CMSIS/STM32F1xx/Source/arm/: startup_stm32f103xb.s
  group HAL_Driver
    ../STM32F10x_Library/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
